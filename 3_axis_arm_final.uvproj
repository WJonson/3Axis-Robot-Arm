# Keil uVision project 3_axis_arm_final.uvproj, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: TM4C123GH6PM Texas Instruments
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(16000000) CPUTYPE("Cortex-M4") FPU2
  output: 3_axis_arm_final
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: rvmdk PART_TM4C123GH6PM TARGET_IS_BLIZZARD_RB1
  c misc: --c99
  c include: ..\..\..\..
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  link misc: --entry Reset_Handler
  group Source Group 1
    ../../../../driverlib/rvmdk/: driverlib.lib
    ./: 3_axis_arm_final.c startup_rvmdk.S
